## boards/shields/macrogears/Kconfig.defconfig
```kconfig
if SHIELD_MACROGEARS

config ZMK_KEYBOARD_NAME
    default "MacroGears"

endif # SHIELD_MACROGEARS
```
